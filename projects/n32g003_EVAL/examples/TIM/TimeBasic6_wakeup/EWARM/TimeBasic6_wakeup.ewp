# IAR project TimeBasic6_wakeup.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G003F5 Nations N32G003F5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G003; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g003_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TimeBasic6_wakeup.bin
  ILINK.IlinkOutputFile: TimeBasic6_wakeup.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g003.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g003_std_periph_driver/src/: misc.c n32g003_dbg.c n32g003_exti.c n32g003_flash.c n32g003_gpio.c n32g003_pwr.c n32g003_rcc.c n32g003_tim.c n32g003_uart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g003_EWARM.S
  group USER
    ../src/: main.c n32g003_it.c
