# IAR project SPI_FullDuplex_Master.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G003F5 Nations N32G003F5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G003; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g003_std_periph_driver\inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_FullDuplex_Master.bin
  ILINK.IlinkOutputFile: SPI_Flash.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g003.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g003_std_periph_driver/src/: n32g003_gpio.c n32g003_rcc.c n32g003_spi.c n32g003_uart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g003_EWARM.S
  group USER
    ../src/: bsp_spi_master.c main.c n32g003_it.c
